# Keil uVision project Sensor_ECU.uvprojx, settings and files
target Sensor_ECU (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sensor_ECU
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Application\inc;.\HAL\inc;.\Driver\inc;.\Common\inc;.\Middleware\VL53L1X\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Applicaton
    ./Application/inc/: app_main.h sensor_manager.h sensor_state_machine.h sensor_task.h
    ./Application/src/: app_main.c sensor_manager.c sensor_state_machine.c sensor_task.c
  group HAL
    ./HAL/inc/: hal_can.h hal_mpu.h hal_vl53.h
    ./HAL/src/: hal_can.c hal_mpu.c hal_vl53.c
  group Driver
    ./Driver/inc/: drv_gpio.h drv_can.h drv_i2c.h drv_timer.h drv_uart.h
    ./Driver/src/: drv_gpio.c drv_can.c drv_i2c.c drv_timer.c drv_uart.c
  group Common
    ./Common/inc/: config.h error.h macro.h types.h
  group VL53L1X
    ./Middleware/VL53L1X/inc/: vl53l1_platform.h VL53L1X_api.h VL53L1X_calibration.h vl53l1_types.h
    ./Middleware/VL53L1X/src/: vl53l1_platform.c VL53L1X_api.c VL53L1X_calibration.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
